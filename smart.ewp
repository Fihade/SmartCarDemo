# IAR project smart.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: source; source\common; source\cpu; source\drivers; source\schedule; D:\Program Files\IAR Systems\Embedded Workbench 6.0 Evaluation\arm\lib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: smart.srec
  ILINK.IlinkOutputFile: IAR_K60N512.out
  ILINK.IlinkIcfFile: D:\2017校内赛摄像头四轮例程\source\link\Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: source; source\common; source\cpu; source\drivers; source\schedule; source\pid; source\link\Pflash.icf
  ILINK.IlinkOutputFile: smart.out
  ILINK.IlinkIcfFile: source\link\Pflash.icf
  group source
    source/: main.c
  group source/common
    source/common/: common.h keyboard.c keyboard.h keyboard_oled.c keyboard_oled.h print.c print.h systeminit.c systeminit.h
  group source/cpu
    source/cpu/: clkinit.c clkinit.h core.c core.h crt0.s start.c start.h vectors.c vectors.h
  group source/drivers
    source/drivers/: 3IN1.c 3IN1.h adc.c adc.h gpio.c gpio.h i2c.c i2c.h i2chard.c i2chard.h interrupt.c interrupt.h mcg.c mcg.h pulse_counter.c pulse_counter.h pwm.c pwm.h sccb.c sccb.h spi.c spi.h timer.c timer.h uart.c uart.h wdog.c wdog.h
  group source/link
    source/link/: Pflash.icf Ram.icf
  group source/pid
    source/pid/: pid.c pid.h
  group source/schedule
    source/schedule/: schedule.c schedule.h
